# Keil uVision project Control velocity.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Control velocity
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c main.h direction.c direction.h dma.c dma.h encoder.c encoder.h PID.c PID.h PWM.c PWM.h timer3.c timer3.h usart_lib.c usart_lib.h systick_time.c systick_time.h
software components: CMSIS:CORE 6.0.0, Device:Startup 1.0.0
